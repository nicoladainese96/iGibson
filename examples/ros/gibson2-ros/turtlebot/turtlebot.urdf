Commit message: fix simulator and launch script

File: examples/ros/gibson2-ros/turtlebot/turtlebot.urdf (robot description, URDF)
Before this commit: robot turtlebot, 36 links, 35 joints
Joints:
- joint camera_rgb_joint: origin xyz=0.1233 0.0 0.565 rpy=0 0 0 -> xyz=-0.087 -0.0125 0.287 rpy=0 0 0
